# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\user\api\inc;.\user;.\STM32F10x_StdPeriph_Driver\inc;E:\keil-527\Packs\ARM\CMSIS\5.5.1\CMSIS\Core\Include;.\Mqtt;.\FreeTROS\inc;.\FreeTROS\port\RVDS\ARM_CM3;.\FreeTROS;.\LVGL;.\LVGL\porting;.\LVGL\app;.\LVGL\src;.\LVGL\src\lv_core;.\LVGL\src\lv_draw;.\LVGL\src\lv_font;.\LVGL\src\lv_hal;.\LVGL\src\lv_misc;.\LVGL\src\lv_themes;.\LVGL\src\lv_widgets;.\LVGL\src\lv_gpu;.\LVGL\app\guider_customer_fonts;.\LVGL\app\guider_fonts;.\LVGL\app\images
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group lib
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group startup
    ./startup/: startup_stm32f10x_hd.s
  group mqtt
    ./Mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group user
    ./user/: main.c stm32f10x_it.c system_stm32f10x.c
    ./FreeTROS/: FreeRTOSConfig.h
  group api
    ./user/api/src/: bep.c delay.c key.c led.c relay.c rgb.c pwm.c kqm.c su_03t.c dht11.c jx_uart_send.c bh1750.c Myi2c_bh1750.c rtc.c flash.c stm32_eval_spi_flash.c bsp_lcd.c light.c usart1.c esp8266.c tim.c
  group rtos/src
    ./FreeTROS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group rtos/port
    ./FreeTROS/port/MemMang/: heap_4.c
    ./FreeTROS/port/RVDS/ARM_CM3/: port.c
  group Lvgl/app
    ./LVGL/app/: events_init.c gui_guider.c setup_scr_screen_data.c setup_scr_screen_open.c setup_scr_screen_wifi.c
    ./LVGL/app/images/: _beijing_alpha_240x320.c _ch2o_alpha_30x30.c _co2_alpha_30x30.c _hum_alpha_30x30.c _light_alpha_50x50.c _noWIFI_alpha_20x20.c _tem_alpha_30x30.c _voc_alpha_30x30.c _wifi_alpha_20x20.c _yanwu_alpha_60x30.c _zhutou_alpha_100x100.c
    ./LVGL/app/guider_fonts/: lv_font_ArchitectsDaughter_16.c lv_font_SIMLI_16.c lv_font_SIMLI_25.c lv_font_simsun_12.c lv_font_simsun_16.c
  group Lvgl/porting
    ./LVGL/: lv_conf.h
    ./LVGL/porting/: lv_port_disp.c
  group Lvgl/src
    ./LVGL/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ./LVGL/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./LVGL/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./LVGL/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./LVGL/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./LVGL/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ./LVGL/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
software components: CMSIS:CORE 5.2.0
